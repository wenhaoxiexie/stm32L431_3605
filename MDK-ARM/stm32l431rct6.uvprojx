# Keil uVision project stm32l431rct6.uvprojx, settings and files
target stm32l431rct6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: NewBoard +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./output/newboard.bin  ./stm32l431rct6/NewBoard.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;                                                                                                                                                 ../Drivers/STM32L4xx_HAL_Driver/Inc;                                                                                                                                                 ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                                                                                                                                                 ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                                                                                                                                                 ../Drivers/CMSIS/Include;                                                                                                                                                 ..\User\Drivers\inc;                                                                                                                                                 ..\User\Application\inc;                                                                                                                                                 ..\User\rc663\intfs;                                                                                                                                                 ..\User\rc663\types;                                                                                                                                                 ..\User\rc663\comps\phhalHw\src\Rc663;                                                                                                                                                 ..\User\rc663\comps\phbalReg\src\Stub;                                                                                                                                                 ..\User\rc663\comps\phKeyStore\src\Rc663;                                                                                                                                                 ..\User\rc663\phSubBal\include;                                                                                                                                                 ..\User\rc663\comps\plLpcd\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group User/Drivers
    ../User/Drivers/src/: 74hc595.c apt8l16.c delay.c ssd1305.c stmflash.c win6170.c hsj08.c nfc9883.c
  group User/App
    ../User/Application/src/: menu.c user_operator.c keyboard.c fpcst90x.c flash.c nfc.c wifi_8266.c
  group RF9883lib
    ../User/rc663/comps/phhalHw/src/: phhalHw.c
    ../User/rc663/comps/phbalReg/src/: phbalReg.c
    ../User/rc663/comps/phbalReg/src/Stub/: phbalReg_Stub.c
    ../User/rc663/comps/phpalI14443p3a/src/: phpalI14443p3a.c
    ../User/rc663/comps/phpalI14443p3a/src/Sw/: phpalI14443p3a_Sw.c
    ../User/rc663/comps/phpalI14443p3b/src/: phpalI14443p3b.c
    ../User/rc663/comps/phpalI14443p3b/src/Sw/: phpalI14443p3b_Sw.c
    ../User/rc663/comps/phpalI14443p4/src/: phpalI14443p4.c
    ../User/rc663/comps/phpalI14443p4/src/Sw/: phpalI14443p4_Sw.c
    ../User/rc663/comps/phpalMifare/src/: phpalMifare.c
    ../User/rc663/comps/phpalMifare/src/Sw/: phpalMifare_Sw.c
    ../User/rc663/comps/phhalHw/src/Rc663/: phhalHw_Rc663.c phhalHw_Rc663_Cmd.c phhalHw_Rc663_Int.c phhalHw_Rc663_Wait.c
    ../User/rc663/comps/phKeyStore/src/Rc663/: phKeyStore_Rc663.c
    ../User/rc663/comps/phLog/src/: phLog.c
    ../User/rc663/comps/phKeyStore/src/: phKeyStore.c
    ../User/rc663/comps/phalMfc/src/: phalMfc.c phalMfc_Int.c
    ../User/rc663/comps/phalMfc/src/Sw/: phalMfc_Sw.c
    ../User/rc663/comps/phpalI18092mPI/src/: phpalI18092mPI.c
    ../User/rc663/comps/phTools/src/: phTools.c
    ../User/rc663/phSubBal/src/: RegCtl_SpiHw.c
  group third_so
    ../User/rc663/: nfc9883.lib STM32.lib
software components: CMSIS:CORE 5.0.1
